Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-03-30T11:27:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.60.25 - Exporter 21.1.60.25 - Alternate UI 21.1.60.25
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 30 11:27:54 2023 * Host: CHATPONG-DEE * Database: C:\Users\CHATPONG\AppData\Local\Temp\33ca801e-a51f-49a0-bfac-93a2148b4abb\3771dc75-3e90-4323-9c6f-753841405c31\ifc * Database version: 5507 * Database creation date: Thu Mar 30 11:27:53 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 30 11:27:53 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 30 11:27:53 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFlowTerminal: FFAS1386-908500BC0_REVIT:Acacia E Toilet Brush, FFAS1386-908500BC0_REVIT:Acacia E Toilet Brush:351972
In: Level 1
Type - Material: Chrome, Plastic, Opaque White, Glass
Type - Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: Acacia E Toilet Brush
Material: Plastic, Opaque White, Chrome, Glass
Pset_DistributionFlowElementCommon - Reference: Acacia E Toilet Brush; sets with these values: 2
